# Keil uVision project usb_cdc_demo.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.4.5.1
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usb_cdc_demo
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: PRODUCT_VERSION=2523 MTK_USB_DEMO_ENABLED
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt2523\inc;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\kernel\service\inc;..\src\usb_demo;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __Vectors
  group app
    ../src/: main.c
  group driver
    ../../../../../driver/chip/mt2523/src/: hal_nvic.c hal_nvic_internal.c hal_gpio.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_flash_mtd_dal.c hal_flash_mtd_common.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_pdma_internal.c hal_cache.c hal_cache_internal.c hal_emi.c hal_gpt.c hal_gpt_internal.c hal_clock_internal.c hal_pmu_wrap_interface.c hal_log.c hal_rtc.c hal_eint.c hal_eint_internal.c hal_usb.c hal_usb_phy.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_mpu.c hal_mpu_internal.c hal_misc.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c
  group cmsis
    ./: startup_mt2523.s
    ../src/: system_mt2523.c
  group lib
    ../../../../../prebuilt/driver/chip/mt2523/lib/: libhal_core_CM4_Keil.lib
  group usb_demo
    ../src/usb_demo/: usb.c usb_custom.c usb_main.c usb_resource.c usbacm_drv.c
