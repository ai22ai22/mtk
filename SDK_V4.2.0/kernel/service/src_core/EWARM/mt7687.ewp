# IAR project mt7687.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PRODUCT_VERSION=7687; MTK_NVDM_ENABLE
  ICCARM.CCIncludePath2: inc; ..\..\inc; ..\..\..\rtos\FreeRTOS\Source\include; ..\..\..\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\rtos\FreeRTOS\inc; ..\..\..\..\driver\chip\inc; ..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\driver\CMSIS\Include; ..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\..\driver\chip\mt7687\src\common\include; ..\..\..\..\middleware\MTK\nvdm\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: mt7687.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: context_info_save.c exception_handler.c syslog.c toi.c
