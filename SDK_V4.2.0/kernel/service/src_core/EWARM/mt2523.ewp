# IAR project mt2523.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PRODUCT_VERSION=2523; MTK_PORT_SERVICE_ENABLE; MTK_NVDM_ENABLE
  ICCARM.CCIncludePath2: inc; ..\..\inc; ..\..\..\rtos\FreeRTOS\Source\include; ..\..\..\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\driver\chip\inc; ..\..\..\..\driver\chip\mt2523\inc; ..\..\..\..\driver\CMSIS\Include; ..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\middleware\MTK\port_service\inc; ..\..\..\..\middleware\MTK\bluetooth\inc; ..\..\..\..\middleware\MTK\nvdm\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mt2523.srec
  ILINK.IlinkOutputFile: mt2523.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: context_info_save.c exception_handler.c syslog.c toi.c
