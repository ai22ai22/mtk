# IAR project ble_serial.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PRODUCT_VERSION=7697; MTK_FLASH_DIRECT_DL; MTK_PATCH_DL_ENABLE; MTK_BSPEXT_ENABLE; MTK_LWIP_ENABLE; MTK_WIFI_TGN_VERIFY_ENABLE; MTK_WIFI_REPEATER_ENABLE; MTK_DEBUG_LEVEL_INFO; MTK_HCI_CONSOLE_MIX_ENABLE; __BT_DEBUG__; MTK_MINISUPP_ENABLE; USE_HAL_DRIVER; MTK_EXTERNAL_FLASH_ENABLE; MTK_NVDM_ENABLE; MTK_BT_NOTIFY_ENABLE; MTK_FOTA_ENABLE; MTK_FOTA_ON_7687
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\rtos\FreeRTOS\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\middleware\MTK\dhcpd\inc; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7687\src\common\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\project\common\bsp_ex\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\third_party\ping\inc; ..\..\..\..\..\middleware\MTK\smtcn\inc; ..\..\..\..\..\middleware\MTK\iperf\inc; ..\..\..\..\..\project\linkit7697_hdk\apps\ble_smart_connect\inc; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\driver\board\linkit7697_hdk\util\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\middleware\MTK\bluetooth\inc; ..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc; ..\..\..\..\..\middleware\MTK\ble_smtcn\inc; ..\..\..\..\..\driver\board\linkit7697_hdk\ept\inc; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\driver\board\linkit7697_hdk\external_flash\inc; ..\..\..\..\..\middleware\MTK\connsys\inc; ..\..\..\..\..\middleware\MTK\bt_notify\inc; ..\..\..\..\..\middleware\MTK\bt_notify\inc\dogp; ..\..\..\..\..\middleware\MTK\bt_callback_manager\inc; ..\..\..\..\..\middleware\MTK\fota\inc; ..\..\..\..\..\middleware\MTK\fota\inc\internal; ..\..\..\..\..\middleware\MTK\tftp\inc; ..\..\..\..\..\middleware\third_party\httpclient\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: ble_serial.bin
  ILINK.IlinkOutputFile: ble_serial.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group apps
    ../../../../../middleware/third_party/mbedtls/library/: aes.c
    ../src/: bt_common.c bt_hci_log_uart.c bt_init.c ept_eint_var.c ept_gpio_var.c gatt_service.c main.c sys_init.c
  group ble
    ../../../../../middleware/MTK/bluetooth/src/: bt_debug.c bt_hci_log.c bt_os_layer_api.c bt_task.c
    ../../../../../prebuilt/middleware/MTK/bluetooth/lib/: libble_iar.a libbtdriver_7697_iar.a
  group bsp
    ../../../../../driver/board/linkit7697_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../middleware/MTK/wifi_service/combo/src/: get_profile_string.c inband_queue_option.c misc.c wifi_channel.c wifi_os_api.c wifi_profile.c wifi_wps.c
    ../../../../../prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_supp/: libwifi_CM4_IAR.a
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
    ../../../../../middleware/MTK/wifi_service/combo/src/init/: wifi_default_config.c wifi_init.c
  group bspex
    ../../../../common/bsp_ex/src/: lp_ex_sleep.c
  group bt_callback_manager
    ../../../../../middleware/MTK/bt_callback_manager/src/: bt_callback_manager.c
  group bt_notify
    ../../../../../middleware/MTK/bt_notify/src/dogp/: ble_dogp_adp_service.c ble_dogp_common.c ble_dogp_service.c
    ../../../../../middleware/MTK/bt_notify/src/: bt_notify_conversion.c bt_notify_data_parse.c bt_notify_list.c bt_notify_task.c bt_spp_dummy.c xml_main.c
    ../../../../../prebuilt/middleware/MTK/bt_notify/lib/: libbtnotify_IAR.a
  group cmsis
    ./: startup_mt7687.s
    ../src/: system_mt7687.c
  group dhcpd
    ../../../../../middleware/MTK/dhcpd/src/: dhcpd.c
  group driver
    ../../../../../driver/board/linkit7697_hdk/external_flash/src/: bsp_flash_config.c
    ../../../../../middleware/MTK/connsys/src/: connsys_bus.c connsys_driver.c connsys_util.c
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_gpc.c hal_gpio_7687.c hal_I2C.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../driver/chip/mt7687/src/: hal_adc.c hal_aes.c hal_cache.c hal_cache_internal.c hal_des.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_nvic.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_uart.c hal_wdt.c
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group fota
    ../../../../../middleware/MTK/fota/src/: fota.c
    ../../../../../middleware/MTK/fota/src/internal/: fota_cli.c fota_config.c fota_download_interface.c fota_internal.c fota_port.c
  group iarfs
    $EW_DIR$/arm/src/lib/file/: close.c lseek.c open.c read.c remove.c rename.c write.c
  group kernel
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c syslog.c toi.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/mt7687/: port_tick.c
  group kservice
    ../../../../../kernel/service/src/: memory_regions.c os_cli.c os_port_callback.c syslog_cli.c
  group lwip
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
    ../../../../../middleware/third_party/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../../../../../middleware/third_party/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c ppp.c pppcrypt.c pppoe.c pppos.c upap.c utils.c vj.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c ip4.c ip4_addr.c ip_frag.c
    ../../../../../middleware/third_party/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c lwip_timers.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c udp.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/netif/: etharp.c slipif.c
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c lwip_cli.c lwip_log.c pbuf.c sys_arch.c tcp_out.c
  group minisupp
    ../../../../../prebuilt/middleware/MTK/minisupp/lib/: libminisupp_CM4_IAR.a
  group N9
    ../../../../../tools/iar/mt7687/N9/: mt76X7_n9_image.c
  group nvdm
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
