# IAR project watch_ref_design.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=2523; MTK_SENSOR_BIO_USE; MTK_SENSOR_BIO_USE_MT2511; MT2511_USE_SPI; USE_EXTERNAL_BOOST; FUSION_HEART_RATE_MONITOR_USE=M_INHOUSE_HEART_RATE_MONITOR; FUSION_BLOOD_PRESSURE_USE=M_INHOUSE_BLOOD_PRESSURE; SENSOR_FUSTION_TASK_ENABLED; SENSOR_DEMO; MTK_USB_DEMO_ENABLED; DYNAMIC_BITMAP_LOADER; MTK_PORT_SERVICE_ENABLE; MTK_ATCI_VIA_PORT_SERVICE; MTK_AT_CMD_DISABLE; MTK_ATCI_VIA_PORT_SERVICE; __USB_MASS_STORAGE_ENABLE__; MTK_NVDM_ENABLE; MTK_CTP_ENABLE; __BT_DEBUG__
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\..\..\..\..\project\mt2523_hdk\apps\watch_ref_design\src\ui\gui\include; ..\src\ui\gui\include\gui\common; ..\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt2523\inc; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\driver\board\mt25x3_hdk\mems_init; ..\..\..\..\..\driver\board\mt25x3_hdk\lcd; ..\..\..\..\..\driver\board\mt25x3_hdk\backlight; ..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\third_party\touchgfx\inc; ..\..\..\..\..\middleware\third_party\touchgfx\inc\touchgfx; ..\..\..\..\..\middleware\third_party\touchgfx\inc\touchgfx/hal; ..\..\..\..\..\project\mt2523_hdk\apps\watch_ref_design\src\ui\gui\include\gui\home_screen; ..\..\..\..\..\project\mt2523_hdk\apps\watch_ref_design\src\ui\gui\include\gui\main_screen; ..\..\..\..\..\project\mt2523_hdk\apps\watch_ref_design\src\ui\gui\include\gui\setting_screen; ..\..\..\..\..\project\mt2523_hdk\apps\watch_ref_design\src\ui\gui\include\gui\graph_screen; ..\..\..\..\..\project\mt2523_hdk\apps\watch_ref_design\src\ui\gui\include\gui\model; ..\..\..\..\..\project\mt2523_hdk\apps\watch_ref_design\src\ui\gui\include\gui\data; ..\..\..\..\..\project\mt2523_hdk\apps\watch_ref_design\src\generated\fonts\include; ..\..\..\..\..\project\mt2523_hdk\apps\watch_ref_design\src\generated\images\include; ..\..\..\..\..\project\mt2523_hdk\apps\watch_ref_design\src\generated\texts\include; ..\..\..\..\..\project\mt2523_hdk\apps\watch_ref_design\inc\sensor_demo; ..\..\..\..\..\driver\board\component\mems\inc; ..\..\..\..\..\driver\board\component\biosensor\mt2511\inc; ..\..\..\..\..\driver\board\component\biosensor\mt2511\module\default; ..\..\..\..\..\middleware\MTK\sensor_subsys\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\common\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\heart_rate\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\ppg_control\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fusion_algo\blood_pressure\inc; ..\..\..\..\..\driver\board\component\common; ..\..\..\..\..\driver\board\component\touch_panel\common\inc; ..\..\..\..\..\driver\board\component\touch_panel\ctp_ite_it7xxx\it7258; ..\..\..\..\..\driver\board\mt25x3_hdk\keypad\inc; ..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\config; ..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\it7258; ..\..\..\..\..\driver\board\mt25x3_hdk\touch_panel\gt9137; ..\..\..\..\..\middleware\MTK\gnss\inc; ..\..\..\..\..\project\mt2523_hdk\apps\watch_ref_design\inc\gnss_demo; ..\..\..\..\..\middleware\MTK\usb\inc; ..\..\..\..\..\middleware\MTK\battery_management\inc; ..\..\..\..\..\middleware\MTK\battery_management\port\mt2523\inc; ..\..\..\..\..\prebuilt\middleware\MTK\fuelgauge\inc; ..\inc\Notification; ..\..\..\..\..\middleware\MTK\bluetooth\inc; ..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc; ..\..\..\..\..\middleware\MTK\ble_ancs\inc; ..\..\..\..\..\prebuilt\middleware\MTK\ble_ancs\inc; ..\..\..\..\..\middleware\MTK\bt_notify\inc\dogp; ..\..\..\..\..\middleware\MTK\bt_notify\inc; ..\..\..\..\..\middleware\MTK\bt_callback_manager\inc; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\lzma_decoder\inc; ..\..\..\..\..\middleware\MTK\port_service\inc; ..\..\..\..\..\middleware\MTK\atci\inc; ..\src\ui\gui\include\gui\database
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: watch_ref_design.bin
  ILINK.IlinkOutputFile: watch_ref_design.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree; --redirect _ZN8touchgfx12TextProvider10initializeEPKt9__va_list=_ZN8touchgfx12TextProvider10initializeEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKc9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKc8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKt9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthLTREhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthLTREhPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthRTLEhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthRTLEhPKt8_VA_LIST
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group app
    ../src/: ept_eint_var.c ept_gpio_var.c sys_init.c
    ../src/sensor_demo/: sensor_demo.c
  group app_enter
    ../src/ui/gui/src/: BoardConfiguration.cpp
    ../src/: main.cpp
  group board
    ../../../../../driver/board/component/touch_panel/common/src/: bsp_ctp.c ctp.c ctp_i2c.c
    ../../../../../driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/component/touch_panel/ctp_goodix_gt9xxx/gt9137/: ctp_goodix_gt9xxx.c
    ../../../../../driver/board/component/touch_panel/ctp_ite_it7xxx/it7258/: ctp_ite_it7xxx.c ctp_ite_it7xxx_download.c
    ../../../../../driver/board/mt25x3_hdk/keypad/src/: keypad_custom.c
    ../../../../../driver/board/component/lcm/ST7789H2/: lcd.c
    ../../../../../driver/board/component/lcm/RM69032/: lcd_RM69032.c
    ../../../../../driver/board/mt25x3_hdk/backlight/: mt25x3_hdk_backlight.c
    ../../../../../driver/board/mt25x3_hdk/lcd/: mt25x3_hdk_lcd.c
    ../../../../../driver/board/mt25x3_hdk/touch_panel/gt9137/: touch_panel_custom_goodix.c
    ../../../../../driver/board/mt25x3_hdk/touch_panel/it7258/: touch_panel_custom_ite.c
  group cmsis
    ./: startup_mt2523.s
    ../src/: system_mt2523.c
  group driver
    ../../../../../driver/chip/mt2523/src/: hal_accdet.c hal_accdet_internal.c hal_adc.c hal_audio.c hal_audio_custom.c hal_audio_enhancement.c hal_audio_fw_interface.c hal_audio_fw_slt.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_internal_vm.c hal_audio_low_power.c hal_audio_post_processing.c hal_audio_test.c hal_bsi.c hal_cache.c hal_cache_internal.c hal_charger.c hal_clock_internal.c hal_dac.c hal_dcm.c hal_dcxo.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_g2d.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_i2s.c hal_i2s_internal.c hal_i2s_internal_pcm_route.c hal_isink.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_log.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pmu_wrap_interface.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_usb.c hal_usb_phy.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_weak.c
  group generated_fonts
    ../src/generated/fonts/src/: ApplicationFontProvider.cpp Font_SourceSansPro_Regular_14_4bpp.cpp Font_SourceSansPro_Regular_20_4bpp.cpp Font_SourceSansPro_Regular_24_4bpp.cpp Font_SourceSansPro_Regular_32_4bpp.cpp Font_SourceSansPro_Regular_64_4bpp.cpp FontGetters.cpp Kerning_SourceSansPro_Regular_14_4bpp.cpp Kerning_SourceSansPro_Regular_20_4bpp.cpp Kerning_SourceSansPro_Regular_24_4bpp.cpp Kerning_SourceSansPro_Regular_32_4bpp.cpp Kerning_SourceSansPro_Regular_64_4bpp.cpp Table_SourceSansPro_Regular_14_4bpp.cpp Table_SourceSansPro_Regular_20_4bpp.cpp Table_SourceSansPro_Regular_24_4bpp.cpp Table_SourceSansPro_Regular_32_4bpp.cpp Table_SourceSansPro_Regular_64_4bpp.cpp
  group generated_images
    ../src/generated/images/src/: BitmapDatabase.cpp
    ../src/generated/images/src/MainMenu/: clock_center_background.int.cpp clock_center_dot.int.cpp icon_battery.int.cpp icon_bluetooth.int.cpp icon_large_heart.int.cpp icon_small_heart.int.cpp menu_clock_background.int.cpp menu_heart_rate_background.int.cpp menu_setting_background.int.cpp menu_stage_stretch_left_side.int.cpp menu_stage_stretch_right_side.int.cpp screen_swipe_dots_active.int.cpp screen_swipe_dots_inactive.int.cpp
    ../src/generated/images/src/Setting/: datepicker_glass_overlay.int.cpp datepicker_main_background.int.cpp datepicker_shadow_overlay.int.cpp icon_back.int.cpp icon_save.int.cpp list_element_0.int.cpp list_element_1.int.cpp list_element_2.int.cpp switch_off.int.cpp switch_on.int.cpp timepicker_glass_overlay.int.cpp timepicker_main_background.int.cpp timepicker_shadow_overlay.int.cpp
  group generated_texts
    ../src/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group gui
    ../src/ui/gui/src/graph_screen/: AbstractGraph.cpp Graph.cpp GraphBelow.cpp GraphDots.cpp GraphLine.cpp PainterColoredBitmap.cpp PainterVerticalAlpha.cpp
    ../src/ui/gui/src/common/: CommonService.cpp DemoPresenter.cpp FrontendApplication.cpp
    ../src/ui/gui/src/setting_screen/: DatePicker.cpp MenuListElement.cpp SetDatePresenter.cpp SetDateView.cpp SetHeartRatePresenter.cpp SetHeartRateView.cpp SetTimePresenter.cpp SetTimeView.cpp SettingPresenter.cpp SettingView.cpp TimePicker.cpp WheelSelector.cpp WheelSelectorExtra.cpp
    ../src/ui/gui/src/main_menu_screen/: DotIndicator.cpp MainMenuPresenter.cpp MainMenuView.cpp SwipeContainer.cpp
    ../src/ui/gui/src/database/: heart_rate_db.cpp
    ../src/ui/gui/src/model/: Model.cpp
  group kernel
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c syslog.c toi.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/mt2523/: port_tick.c
  group kservice
    ../../../../../kernel/service/src/: memory_regions.c os_port_callback.c
  group lib
    ../../../../../prebuilt/middleware/MTK/ble_ancs/lib/: libbleancs_IAR.a
    ../../../../../prebuilt/middleware/MTK/bluetooth/lib/: libbt_iar.a libbt_spp_iar.a libbt_driver_2523_iar.a
    ../../../../../prebuilt/middleware/MTK/bt_notify/lib/: libbtnotify_IAR.a
    ../../../../../prebuilt/middleware/MTK/fuelgauge/lib/: libfgauge_IAR.a
    ../../../../../prebuilt/driver/chip/mt2523/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
    ../../../../../middleware/third_party/touchgfx/lib/core/cortex_m4f/IAR/: touchgfx_core.a
  group mems
    ../../../../../driver/board/component/mems/src/: bma255_i2c_operation.c bma255_sensor_adaptor.c bma2x2.c mems_bus.c sensor_manager_driver.c
    ../../../../../driver/board/mt25x3_hdk/mems_init/: mems_init.c
    ../../../../../driver/board/component/biosensor/mt2511/src/: vsm_driver.c vsm_i2c_operation.c vsm_platform_function.c vsm_sensor_subsys_adaptor.c vsm_spi_operation.c
  group nvdm
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
  group sensor_fusion
    ../../../../../middleware/MTK/sensor_subsys/src/algo_adaptor/: algo_adaptor.c blood_pressure_monitor_adaptor.c heart_rate_monitor_adaptor.c
    ../../../../../prebuilt/middleware/MTK/fusion_algo/blood_pressure/lib_core/: libbp_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fusion_algo/common/lib_core/: libcomm_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fusion_algo/heart_rate/lib_core/: libhr_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fusion_algo/ppg_control/lib_core/: libppgctrl_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/fusion_algo/ppg_control/module/default/: ppg_control_module.c
  group sensor_subsys
    ../../../../../middleware/MTK/sensor_subsys/src/: sensor_manager.c
  group touchgfxHAL
    ../../../../../middleware/third_party/touchgfx/src/: CortexMMCUInstrumentation.cpp GPIO.cpp mt2523DMA.cpp mt2523HAL.cpp OSWrappers.cpp
    ../src/touch_adapter/: mt2523TouchController.cpp
  group usb
    ../../../../../middleware/MTK/usb/src/_common/: usb.c usb_custom.c usb_main.c usb_resource.c
    ../../../../../middleware/MTK/usb/src/cdc/: usbacm_adap.c usbacm_drv.c
    ../../../../../middleware/MTK/usb/src/msc/: usbms_adap.c usbms_drv.c usbms_msdc.c usbms_state.c
