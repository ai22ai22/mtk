# Keil uVision project xml.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.6.0
  cpu: IROM(0x10000000,0x00400000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: xml
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: PRODUCT_VERSION=7687 USE_HAL_DRIVER PCFG_OS=2 _REENT_SMALL PRODUCT_VERSION=7687 MTK_SYS_TRNG_ENABLE MTK_NVDM_ENABLE MTK_MINISUPP_ENABLE MTK_PING_OUT_ENABLE MTK_IPERF_ENABLE MTK_BSPEXT_ENABLE  MTK_FOTA_ON_7687 MTK_LWIP_ENABLE MBEDTLS_CONFIG_FILE="config-mtk-basic.h"  CFG_SUPPORT_SMNT_PROTO=2 MTK_DEBUG_LEVEL_INFO MTK_DEBUG_LEVEL_WARNING MTK_DEBUG_LEVEL_ERROR
  c misc: --c99 --diag_suppress=161 --diag_suppress=1295
  c include: ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\inc;..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\chip\mt7687\include;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\..\middleware\MTK\tftp\inc;..\..\..\..\..\middleware\MTK\fota\inc;..\..\..\..\..\middleware\MTK\fota\inc\76x7;..\..\..\..\..\middleware\third_party\cjson\inc;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\middleware\MTK\dhcpd\inc;..\..\..\..\..\middleware\third_party\httpclient\inc;..\..\..\..\..\middleware\third_party\mbedtls\include;..\..\..\..\..\middleware\third_party\mbedtls\configs;..\..\..\..\..\middleware\MTK\minicli\inc;..\..\..\..\..\middleware\MTK\minisupp\inc;..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc;..\..\..\..\..\middleware\MTK\minisupp\include;..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src\mt7687;..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src;..\..\..\..\..\middleware\third_party\mqtt\MQTTPacket\src;..\..\..\..\..\middleware\third_party\nghttp2\lib\includes;..\..\..\..\..\middleware\third_party\nghttp2\lib\includes\nghttp2;..\..\..\..\..\middleware\MTK\smtcn\inc;..\..\..\..\..\middleware\third_party\sntp\inc;..\..\..\..\..\middleware\third_party\xml\inc;..\..\..\..\..\middleware\third_party\httpd\inc;..\..\..\..\..\middleware\MTK\iperf\inc;..\..\..\..\..\middleware\third_party\ping\inc;..\..\..\..\..\project\common\bsp_ex\inc;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\project\mt7687_hdk\apps\xml\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\MDK-arm;..\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\driver\board\mt76x7_hdk\util\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc;..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc;..\..\..\..\..\middleware\MTK\connsys\inc;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector --keep N9_array
  group app
    ../src/: system_mt7687.c main.c regions_init.c sys_init.c
    ../../xml/src/: xml_test.c
    ../../../../../tools/keil/mt7687/N9/: mt76X7_n9_image.c
  group driver
    ../../../../../driver/chip/mt7687/src/: hal_misc.c hal_des.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_uart.c hal_wdt.c hal_cache_internal.c hal_adc.c hal_aes.c hal_cache.c hal_nvic.c hal_dwt.c
    ../../../../../driver/chip/mt7687/src/common/: dma.c flash_sfc.c gpt.c hal_gpc.c hal_gpio_7687.c hal_I2C.c hal_i2s_internal.c hal_irrx.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c hal_lp.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../middleware/MTK/wifi_service/combo/src/: misc.c
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_utils.c
    ../../../../../middleware/third_party/xml/src/: mxml-attr.c mxml-entity.c mxml-file.c mxml-get.c mxml-index.c mxml-node.c mxml-private.c mxml-search.c mxml-set.c mxml-string.c
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_protected_CM4_Keil.lib libhal_core_CM4_Keil.lib
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c syslog.c toi.c os_port_callback.c
    ../src/: ept_eint_var.c ept_gpio_var.c
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt7687/: port_tick.c
  group cmsis
    ./: startup_mt7687.s
  group nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_KEIL.lib
