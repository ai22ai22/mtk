# Keil uVision project kservice.uvprojx, settings and files
target mt7687 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.1.0
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libkservice_CM4_MT7687_Keil (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: PRODUCT_VERSION=7687 MTK_NVDM_ENABLE
  c include: .\inc;..\..\inc;..\..\..\rtos\FreeRTOS\Source\include;..\..\..\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\driver\chip\inc;..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\driver\CMSIS\Include;..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\middleware\MTK\nvdm\inc
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  group src
    ../: exception_handler.c syslog.c toi.c context_info_save.c
target mt2523 (ARM-ADS)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.4.1.0
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libkservice_CM4_MT2523_Keil (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: PRODUCT_VERSION=2523 MTK_PORT_SERVICE_ENABLE
  c include: .\inc;..\..\inc;..\..\..\rtos\FreeRTOS\Source\include;..\..\..\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\driver\chip\inc;..\..\..\..\driver\chip\mt2523\inc;..\..\..\..\driver\CMSIS\Include;..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\middleware\MTK\port_service\inc;..\..\..\..\middleware\MTK\bluetooth\inc
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
