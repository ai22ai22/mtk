# Keil uVision project nvdm.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.3.3.0
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libnvdm_CM4_KEIL (library)
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: MTK_NVDM_ENABLE
  c include: ..\..\..\inc;..\..\..\inc_core
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  group nvdm
    ../../: nvdm_data.c nvdm_io.c nvdm_main.c
